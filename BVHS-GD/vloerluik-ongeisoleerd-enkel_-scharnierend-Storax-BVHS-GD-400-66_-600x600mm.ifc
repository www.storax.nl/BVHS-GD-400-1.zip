Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 8380ad05-d076-4e4a-8acc-81347f764e84.ifc
Time: 2026-08-11T14:05:21
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, scharnierend Storax - BVHS-GD 400 66, 600x600mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAALZ8dhcFAAAA3esCAAV2SgAA2FMBAInDAADG7AIATuwCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAALZ8dhcFAAAA3esCAAV2SgAA2FMBAInDAADG7AIATuwCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 838 mm; NAA.K.T: samengesteld_product_kozijn; Rc-waarde: 0 m²·k/w; breedte: 752 mm; gewicht per st: 90 kg/st; serie: BVHS-GD 400; afsluitbaar: True; hoogte: 230 mm; merk: Storax; breuklast: D400; type: 66; dagmaatbreedte: 600 mm; omranding: staal; luik: staal; aandrijving: Storax - gasdrukveer
